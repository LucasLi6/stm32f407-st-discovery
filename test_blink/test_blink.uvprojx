# Keil uVision project test_blink.uvprojx, settings and files
target test_blink (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_blink +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32F407xx
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\link.sct
  group Source
    ./: main.c startup_stm32f407xx.s
