# Keil uVision project project.uvprojx, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_ARMLIBC, RT_USING_LIBC, STM32F407xx
  c include: ..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;applications;..\..\..\components\drivers\include;applications\oled;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\libc\posix\io\epoll;.;..\..\..\include;..\libraries\HAL_Drivers;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\HAL_Drivers\config;board\CubeMX_Config\Inc;board;applications\esp8266;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;applications\shell;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: wifi_config.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group esp8266
    applications/esp8266/: esp8266.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cryp.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma_ex.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group oled
    applications/oled/: OLED.c
  group shell
    applications/shell/: shell.c
